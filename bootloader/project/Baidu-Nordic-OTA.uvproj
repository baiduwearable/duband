# Keil uVision project Baidu-Nordic-OTA.uvproj, settings and files
target dfu_dual_bank_ble (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: baidu-ota +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,WT1000, BOOTLOADER_BANKED
  c misc: --c99
  c include: ..\Source\inc;..\nrf51822\Include;..\nrf51822\Include\app_common;..\nrf51822\Include\ble;..\nrf51822\Include\ble\ble_services;..\nrf51822\Include\ble\softdevice
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../nrf51822/Source/templates/: system_nrf51.c
    ../Source/src/: arm_startup_nrf51.s
  group Source Code
    ../Source/src/: main.c dfu_dual_bank.c bootloader.c bootloader_util_arm.c
  group Services
    ../nrf51822/Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../nrf51822/Source/app_common/: app_scheduler.c app_timer.c crc16.c
    ../nrf51822/Source/nrf_nvmc/: nrf_nvmc.c
    ../nrf51822/Source/ble/: ble_flash.c
    ../nrf51822/Source/simple_uart/: simple_uart.c
  group BLE Transport
    ../Source/src/: dfu_transport_ble.c
    ../nrf51822/Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_radio_notification.c
    ../nrf51822/Source/ble/ble_services/: ble_srv_common.c
